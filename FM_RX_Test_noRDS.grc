options:
  parameters:
    generate_options: qt_gui
    id: FM_RX_Test
    output_language: python
    title: FM Stereo MPX Receiver
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: '"Baseband Audio Gain"'
    outputmsgname: value
    showports: 'False'
    start: '0.1'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {}
- name: rx_cutoff
  id: variable_qtgui_range
  parameters:
    label: '"RX Filter Cutoff Frequency"'
    outputmsgname: value
    showports: 'False'
    start: '10000'
    step: '10000'
    stop: '300000'
    value: '100000'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: '"RX Frequency"'
    outputmsgname: value
    showports: 'False'
    start: '87500000'
    step: '100000'
    stop: '108000000'
    value: '103700000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: '"RX Gain"'
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '40'
    value: '15'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: stereo_diff_gain
  id: variable_qtgui_range
  parameters:
    label: '"Stereo L-R Difference Channel Gain"'
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '50'
    value: '12'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: rx_samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: stereo_diff_gain
    high_cutoff_freq: '19500'
    low_cutoff_freq: '18500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: stereo_diff_gain
    high_cutoff_freq: '38500'
    low_cutoff_freq: '37500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: stereo_diff_gain
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: rx_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: rx_samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: rx_cutoff
    decim: '1'
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: bb_gain
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: stereo_diff_gain
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    label1: '"Left Channel"'
    label2: '"Right Channel"'
    name: '"L vs R Spectrum"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    label1: '"Stereo L-R Difference"'
    name: '"Stereo L-R Difference Spectrum"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rx_samp_rate
    ctrlpanel: 'True'
    fc: rx_freq
    fftsize: '1024'
    label1: '"Unfiltered Spectrum"'
    label2: '"Filtered Spectrum"'
    name: '"RX Spectrum"'
    nconnections: '2'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '24'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {}

connections:
- [analog_fm_deemph_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_fm_deemph_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_fm_deemph_0_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_fm_deemph_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_2, '0']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_2, '1']
- [blocks_add_xx_2, '0', analog_fm_deemph_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_xx_2, '0', low_pass_filter_1_0, '0']
- [blocks_sub_xx_1, '0', analog_fm_deemph_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_1_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1_0, '1']
- [low_pass_filter_1, '0', blocks_add_xx_2, '0']
- [low_pass_filter_1, '0', blocks_sub_xx_1, '0']
- [low_pass_filter_1_0, '0', blocks_add_xx_2, '1']
- [low_pass_filter_1_0, '0', blocks_sub_xx_1, '1']
- [low_pass_filter_1_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', band_pass_filter_0_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0_0, '0', audio_sink_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
