options:
  parameters:
    generate_options: qt_gui
    id: FM_TX_Test
    output_language: python
    title: FM Stereo MPX Transmitter
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: '"Baseband Audio Gain"'
    outputmsgname: value
    showports: 'False'
    start: '0.00'
    step: '0.05'
    stop: '10'
    value: '1.5'
  states: {}
- name: outbuffer
  id: variable
  parameters:
    value: '10'
  states: {}
- name: pha_offset
  id: variable_qtgui_range
  parameters:
    label: '"38 kHz Subcarrier Phase"'
    outputmsgname: value
    showports: 'False'
    start: '0.00'
    step: '0.02'
    stop: '3.14'
    value: '0'
  states: {}
- name: pilot_ampl
  id: variable_qtgui_range
  parameters:
    label: '"19 kHz Stereo Pilot Amplitude"'
    outputmsgname: value
    showports: 'False'
    start: '0.00'
    step: '0.05'
    stop: '10'
    value: '0.5'
  states: {}
- name: rds_ampl
  id: variable_qtgui_range
  parameters:
    label: '"57 kHz Subcarrier Amplitude"'
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.1'
    stop: '10.0'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '380000'
  states: {}
- name: sc_ampl
  id: variable_qtgui_range
  parameters:
    label: '"38 kHz Subcarrier Amplitude"'
    outputmsgname: value
    showports: 'False'
    start: '0.00'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    label: '"TX Frequency"'
    outputmsgname: value
    showports: 'False'
    start: '87500000'
    step: '100000'
    stop: '108000000'
    value: '103700000'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    maxoutbuf: outbuffer
    sensitivity: '1.2'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: pilot_ampl
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: sc_ampl
    freq: '38000'
    offset: '0'
    phase: pha_offset
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: rds_ampl
    freq: '57000'
    offset: '0'
    phase: pha_offset
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    maxoutbuf: outbuffer
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    maxoutbuf: outbuffer
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
    maxoutbuf: outbuffer
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: Test_WAV.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    maxoutbuf: outbuffer
    modulus: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1,2]'
    maxoutbuf: outbuffer
  states: {}
- name: iio_pluto_sink_1
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_freq
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    gain: bb_gain
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '76000'
    gain: '1'
    interp: '1'
    maxoutbuf: outbuffer
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    type: fff
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 89.7e6
    ms: 'True'
    pi_country_code: '1'
    pi_coverage_area: '0'
    pi_reference_number: '147'
    ps: RDSTEST
    pty: '7'
    pty_locale: '1'
    radiotext: Snowflake - Give It Up
    ta: 'False'
    tp: 'False'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    gain: '111'
    interp: '160'
    ntaps: 160*11
    samp_rate: samp_rate
    sym_rate: '2375'
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_fm_preemph_0, '0', blocks_add_xx_1, '0']
- [analog_fm_preemph_0, '0', blocks_sub_xx_0, '0']
- [analog_fm_preemph_0_0, '0', blocks_add_xx_1, '1']
- [analog_fm_preemph_0_0, '0', blocks_sub_xx_0, '1']
- [analog_frequency_modulator_fc_0, '0', iio_pluto_sink_1, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_1_0_0, '0', blocks_multiply_xx_1_0, '1']
- [band_pass_filter_1, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', low_pass_filter_0_1, '0']
- [blocks_add_xx_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', band_pass_filter_1, '0']
- [blocks_multiply_xx_1_0, '0', blocks_add_xx_0, '3']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '1', rational_resampler_xxx_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0_1, '0', analog_frequency_modulator_fc_0, '0']
- [low_pass_filter_0_1, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_preemph_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_fm_preemph_0_0, '0']
- [rds_encoder_0, '0', digital_diff_encoder_bb_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
